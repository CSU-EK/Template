# Keil uVision project EK_LCD_F4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EK_LCD_F4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\Core;.\USER;.\OBJ;.\USMART;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HALLIB\STM32F4xx_HAL_Driver\Inc;.\HARDWARE\24CXX;.\HARDWARE\IIC;.\HARDWARE\KEY;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\TOUCH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ./CORE/: cmsis_armcc.h core_cm4.h startup_stm32f407xx.s
  group LIB
    ./HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/IIC/: myiic.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
  group USMART
    ./USMART/: usmart.c usmart_config.c usmart_str.c
