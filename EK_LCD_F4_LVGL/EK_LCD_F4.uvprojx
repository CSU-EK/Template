# Keil uVision project EK_LCD_F4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EK_LCD_F4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\Core;.\USER;.\OBJ;.\USMART;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HALLIB\STM32F4xx_HAL_Driver\Inc;.\HARDWARE\24CXX;.\HARDWARE\IIC;.\HARDWARE\KEY;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\TOUCH;.\LVGL;.\LVGL\src;.\LVGL\examples\porting;.\LVGL\src\misc;.\LVGL\src\core;.\LVGL\src\display;.\LVGL\src\draw;.\LVGL\src\drivers;.\LVGL\src\font;.\LVGL\src\indev;.\LVGL\src\layouts;.\LVGL\src\osal;.\LVGL\src\stdlib;.\LVGL\src\themes;.\LVGL\src\tick;.\LVGL\src\widgets;.\SYSTEM\timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ./CORE/: cmsis_armcc.h core_cm4.h startup_stm32f407xx.s
  group LIB
    ./HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/timer/: timer.c
  group HARDWARE
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/IIC/: myiic.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
  group USMART
    ./USMART/: usmart.c usmart_config.c usmart_str.c
  group LVGL_conf
    ./LVGL/: lv_conf.h lvgl.h
  group LVGL_porting
    ./LVGL/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_src
    ./LVGL/src/: lv_init.c
    ./LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ./LVGL/src/display/: lv_display.c
    ./LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ./LVGL/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ./LVGL/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c
    ./LVGL/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ./LVGL/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ./LVGL/src/draw/opengles/: lv_draw_opengles.c
    ./LVGL/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ./LVGL/src/draw/sdl/: lv_draw_sdl.c
    ./LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ./LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ./LVGL/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ./LVGL/src/drivers/display/drm/: lv_linux_drm.c
    ./LVGL/src/drivers/display/fb/: lv_linux_fbdev.c
    ./LVGL/src/drivers/display/ili9341/: lv_ili9341.c
    ./LVGL/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ./LVGL/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ./LVGL/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ./LVGL/src/drivers/display/st7735/: lv_st7735.c
    ./LVGL/src/drivers/display/st7789/: lv_st7789.c
    ./LVGL/src/drivers/display/st7796/: lv_st7796.c
    ./LVGL/src/drivers/evdev/: lv_evdev.c
    ./LVGL/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c
    ./LVGL/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ./LVGL/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ./LVGL/src/drivers/qnx/: lv_qnx.c
    ./LVGL/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ./LVGL/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c
    ./LVGL/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ./LVGL/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ./LVGL/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./LVGL/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ./LVGL/src/layouts/: lv_layout.c
    ./LVGL/src/layouts/flex/: lv_flex.c
    ./LVGL/src/layouts/grid/: lv_grid.c
    ./LVGL/src/libs/barcode/: code128.c lv_barcode.c
    ./LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ./LVGL/src/libs/bmp/: lv_bmp.c
    ./LVGL/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ./LVGL/src/libs/ffmpeg/: lv_ffmpeg.c
    ./LVGL/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ./LVGL/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./LVGL/src/libs/gif/: gifdec.c lv_gif.c
    ./LVGL/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ./LVGL/src/libs/libpng/: lv_libpng.c
    ./LVGL/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ./LVGL/src/libs/lz4/: lz4.c
    ./LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./LVGL/src/libs/rle/: lv_rle.c
    ./LVGL/src/libs/rlottie/: lv_rlottie.c
    ./LVGL/src/libs/svg/: lv_svg.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ./LVGL/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ./LVGL/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ./LVGL/src/misc/: lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c lv_anim.c
    ./LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ./LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
    ./LVGL/src/others/file_explorer/: lv_file_explorer.c
    ./LVGL/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c lv_font_manager_utils.c
    ./LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./LVGL/src/others/gridnav/: lv_gridnav.c
    ./LVGL/src/others/ime/: lv_ime_pinyin.c
    ./LVGL/src/others/imgfont/: lv_imgfont.c
    ./LVGL/src/others/monkey/: lv_monkey.c
    ./LVGL/src/others/observer/: lv_observer.c
    ./LVGL/src/others/snapshot/: lv_snapshot.c
    ./LVGL/src/others/sysmon/: lv_sysmon.c
    ./LVGL/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ./LVGL/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_utils.c lv_xml_widget.c
    ./LVGL/src/others/xml/parsers/: lv_xml_button_parser.c lv_xml_chart_parser.c lv_xml_image_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_slider_parser.c lv_xml_tabview_parser.c
    ./LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ./LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ./LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ./LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ./LVGL/src/stdlib/: lv_mem.c
    ./LVGL/src/themes/default/: lv_theme_default.c
    ./LVGL/src/themes/mono/: lv_theme_mono.c
    ./LVGL/src/themes/simple/: lv_theme_simple.c
    ./LVGL/src/themes/: lv_theme.c
    ./LVGL/src/tick/: lv_tick.c
    ./LVGL/src/widgets/animimage/: lv_animimage.c
    ./LVGL/src/widgets/arc/: lv_arc.c
    ./LVGL/src/widgets/bar/: lv_bar.c
    ./LVGL/src/widgets/button/: lv_button.c
    ./LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ./LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./LVGL/src/widgets/canvas/: lv_canvas.c
    ./LVGL/src/widgets/chart/: lv_chart.c
    ./LVGL/src/widgets/checkbox/: lv_checkbox.c
    ./LVGL/src/widgets/dropdown/: lv_dropdown.c
    ./LVGL/src/widgets/image/: lv_image.c
    ./LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ./LVGL/src/widgets/keyboard/: lv_keyboard.c
    ./LVGL/src/widgets/label/: lv_label.c
    ./LVGL/src/widgets/led/: lv_led.c
    ./LVGL/src/widgets/line/: lv_line.c
    ./LVGL/src/widgets/list/: lv_list.c
    ./LVGL/src/widgets/lottie/: lv_lottie.c
    ./LVGL/src/widgets/menu/: lv_menu.c
    ./LVGL/src/widgets/msgbox/: lv_msgbox.c
    ./LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ./LVGL/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ./LVGL/src/widgets/roller/: lv_roller.c
    ./LVGL/src/widgets/scale/: lv_scale.c
    ./LVGL/src/widgets/slider/: lv_slider.c
    ./LVGL/src/widgets/span/: lv_span.c
    ./LVGL/src/widgets/spinbox/: lv_spinbox.c
    ./LVGL/src/widgets/spinner/: lv_spinner.c
    ./LVGL/src/widgets/switch/: lv_switch.c
    ./LVGL/src/widgets/table/: lv_table.c
    ./LVGL/src/widgets/tabview/: lv_tabview.c
    ./LVGL/src/widgets/textarea/: lv_textarea.c
    ./LVGL/src/widgets/tileview/: lv_tileview.c
    ./LVGL/src/widgets/win/: lv_win.c
